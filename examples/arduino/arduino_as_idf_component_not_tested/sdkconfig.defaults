## examples/arduino/arduino_as_idf_component_not_tested/sdkconfig.defaults
```kconfig
CONFIG_ARDUINO_SELECTIVE_COMPILATION=y
CONFIG_AUTOSTART_ARDUINO=n
CONFIG_ARDUINO_LOOP_STACK_SIZE=8192
```
